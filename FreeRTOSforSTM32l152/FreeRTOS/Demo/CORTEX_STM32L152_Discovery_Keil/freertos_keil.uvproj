# Keil uVision project freertos_keil.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: freertos_keil
  c flags: Optim=1
  c include: .\include;..\..\Source\include;.\ST_Code\Libraries\CMSIS\Include;.\ST_Code\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\Source\portable\RVDS\ARM_CM3;.\ST_Code\STM32L-DISCOVERY;..\Common\include;.\include;.\System
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: startup_stm32l1xx_md.s main.c main_low_power.c STM32L_low_power_tick_management.c stm32l1xx_it.c
    ./include/: FreeRTOSConfig.h
    ./System/: system_stm32l1xx.c
  group FreeRTOS Source
    ../../Source/portable/MemMang/: heap_4.c
    ../../Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../Source/portable/RVDS/ARM_CM3/: port.c
  group Standard Demo Tasks
    ../Common/Minimal/: BlockQ.c blocktim.c countsem.c dynamic.c GenQTest.c PollQ.c recmutex.c semtest.c
  group STcode
    ./ST_Code/STM32L-DISCOVERY/: stm32l_discovery_lcd.c
    ./ST_Code/Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_opamp.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_usart.c stm32l1xx_wwdg.c
