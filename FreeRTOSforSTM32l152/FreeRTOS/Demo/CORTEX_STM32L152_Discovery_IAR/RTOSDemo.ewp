# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152VB ST STM32L152VB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L1XX_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: include; ST_Code\STM32L-DISCOVERY; ST_Code\libraries\STM32L1xx_StdPeriph_Driver\inc; ST_Code\libraries\STMTouch_Driver\inc; ST_Code\libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\Source\include; ..\..\Source\portable\IAR\ARM_CM3; ..\Common\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: include
  OBJCOPY.OOCOutputFile: RTOSDemo.hex
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    include/: FreeRTOSConfig.h
    ./: main.c main_full.c main_low_power.c stm32l1xx_it.c STM32L_low_power_tick_management.c
  group FreeRTOS Source
    ../../Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS Source/Portable
    ../../Source/portable/MemMang/: heap_4.c
  group FreeRTOS Source/Portable/IAR/ARM_CM3
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group ST_Code/STM32L-Discovery
    ST_Code/STM32L-DISCOVERY/: stm32l_discovery_lcd.c
  group ST_Code/STM32L1xx_StdPeriph_Driver
    ST_Code/Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group Standard Demo Tasks
    ../Common/Minimal/: BlockQ.c blocktim.c countsem.c dynamic.c GenQTest.c PollQ.c recmutex.c semtest.c
  group System
    System/: startup_stm32l1xx_md.s system_stm32l1xx.c
